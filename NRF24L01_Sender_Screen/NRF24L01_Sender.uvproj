# Keil uVision project NRF24L01_Sender.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: NRF24L01_Sender +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\delay;.\uart;.\NRF24L01__Sender;.\nine_key;.\HandSignal
  group Source Group 1
    ./: STARTUP.A51 main_test.c
    ./delay/: delay.c
    ./uart/: uart.c
    ./NRF24L01__Sender/: NRF24L01_Sender.c
    ./nine_key/: key.c
    ./HandSignal/: handsignal.c
