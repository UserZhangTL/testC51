# Keil uVision project NRF24L01_Receiver.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: NRF24L01_Receiver +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\delay;.\uart;.\NRF24L01__Receiver;.\LED16_64;.\WifiESP8266;.\PCF8563;.\DS18B20
  group Source Group 1
    ./: STARTUP.A51 main_test.c
    ./delay/: delay.c
    ./uart/: uart.c
    ./NRF24L01__Receiver/: NRF24L01_Receiver.c
    ./LED16_64/: LED.c zimo.c
    ./WifiESP8266/: WifiESP8266.c
    ./PCF8563/: PCF8563.c
    ./DS18B20/: DS18B20.c
