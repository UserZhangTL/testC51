# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\delay;.\uart;.\tmp_hum_new;.\nine_key
  group Source Group 1
    ./: STARTUP.A51 test.c
    ./delay/: delay.c
    ./uart/: uart.c
    ./tmp_hum_new/: tmp_hum_new.c
    ./nine_key/: key.c
